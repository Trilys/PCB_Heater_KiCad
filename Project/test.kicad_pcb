File: Project/test.kicad_pcb (KiCad board)
At the start: 2 copper layers, 0 parts

Commit message: Up gitignore
Routing:
- net (no net): track 4958.0 -> 4837.3 mm
